Commit message: adding new floor from rachel to fix falling floor problem

File: src/pb_robot/models/short_floor.urdf (robot description, URDF)
Before this commit: robot flat_terrain, 1 links, 0 joints
Links:
- link base_link: mass None -> .0
