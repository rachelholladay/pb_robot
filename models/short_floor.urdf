Commit message: minor adjustments

File: models/short_floor.urdf (robot description, URDF)
Before this commit: robot flat_terrain, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=2000 2000 0.1; visual box size=2000 2000 0.1
